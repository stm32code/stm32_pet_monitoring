# Keil uVision project USART.uvprojx, settings and files
target USART (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\UARTx;..\HARDWARE\ATK-ESP8266;..\HARDWARE\MALLOC;..\HARDWARE\DHT11;..\HARDWARE\ESP8266;..\HARDWARE\ADC;..\HARDWARE\DS18B20;..\HARDWARE\GPIO;..\HARDWARE\CJSON;..\HARDWARE\RFID;..\HARDWARE\PWM;..\HARDWARE\step;..\HARDWARE\servo;..\HARDWARE\TEST;..\HARDWARE\mx30102;..\HARDWARE\OLED;..\HARDWARE\EXIT;..\HARDWARE\ADXL345;..\HARDWARE\IIC;..\HARDWARE\HX711
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MY
    ./: main.c
    ../HARDWARE/UARTx/: uart2.c uart3.c
    ../HARDWARE/ESP8266/: wifi.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/GPIO/: gpio.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../HARDWARE/ADC/: glr_adc.c
    ../HARDWARE/CJSON/: cJSON.c jsonUtil.c
    ../HARDWARE/mx30102/: algorithm.c max30102.c myiic.c
    ../HARDWARE/OLED/: OLED_I2C.c
  group FWLib
    ./: system_stm32f10x.c stm32f10x_it.c
    ../SYSTEM/sys/: sys.c
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_spi.c
